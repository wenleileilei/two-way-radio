# IAR project codec2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; ARM_MATH_CM4; STM32F40_41xxx; CORTEX_M4
  ICCARM.CCIncludePath2: src; stm32\CMSIS\Include; stm32\CMSIS\ST\STM32F4xx\Include; stm32\inc; stm32\CMSIS\Device\ST\STM32F4xx\Include; stm32\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: codec2.bin
  ILINK.IlinkOutputFile: codec2.out
  ILINK.IlinkIcfFile: codec2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 2
  group DSP lib
    stm32/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_bitreversal2.S
  group DSP lib/CommonTables
    stm32/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
  group DSP lib/TransformFunctions
    stm32/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_f32.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
    stm32/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_scale_f32.c
  group EWARM
    stm32/src/: startup_stm32f4xx.s
  group STM32F4xx_StdPeriph_Driver
    stm32/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    stm32/src/: 1278.c codec2_profile.c stm32f4_machdep.c stm32f4xx_it.c system_stm32f4xx.c
    src/: codebook.c codebookd.c codebookge.c codebookjvm.c codec2.c fdmdv.c freedv_api.c golay23.c interp.c kiss_fft.c lpc.c lsp.c modem_stats.c nlp.c pack.c phase.c postfilter.c quantise.c sine.c
